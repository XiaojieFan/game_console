# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32L475xx
  c include: .;rt-thread\include;.;applications;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\rt_ota\inc;libraries\HAL_Drivers\drv_flash;board\ports\easyflash;packages\EasyFlash-v3.3.0\inc;board\ports\fal;packages\fal-latest\inc;board\ports\wifi;libraries\wifi;libraries\rt_ota\inc;libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;libraries\STM32L4xx_HAL\CMSIS\Include;packages\cJSON-latest;packages\netutils-v1.1.0\telnet;packages\peripheral_samples-v0.4.0;packages\rt-robot-latest\chassis;packages\rt-robot-latest\controller;packages\rt-robot-latest\encoder;packages\rt-robot-latest\kinematics;packages\rt-robot-latest\motor;packages\rt-robot-latest\protocol;packages\rt-robot-latest\robot;packages\rt-robot-latest\wheel;packages\stm32_sdio-v1.0.2;packages\tcpserver-latest;rt-thread\libcpu\arm\cortex-m4;rt-thread\libcpu\arm\common;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\wlan;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\net\lwip-2.0.2\src;rt-thread\components\net\lwip-2.0.2\src\include;rt-thread\components\net\lwip-2.0.2\src\include\ipv4;rt-thread\components\net\lwip-2.0.2\src\arch\include;rt-thread\components\net\lwip-2.0.2\src\include\netif;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\dfs_net\sys_select;rt-thread\components\net\sal_socket\include\socket\sys_socket
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c mototest.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    board/ports/: drv_qspi_flash.c
    libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l475xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_pwm.c drv_spi.c drv_qspi.c drv_wlan.c drv_sdio_adapter.c drv_common.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_l4.c
  group EasyFlash
    board/ports/easyflash/: ef_fal_port.c
    packages/EasyFlash-v3.3.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
  group fal
    board/ports/fal/: fal_flash_sfud_port.c fal_flash_stm32l4_port.c
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group wifi
    board/ports/wifi/: wifi_config.c
  group wifi
    libraries/wifi/: libwifi_6181_0.2.5_armcm4_keil.lib
  group rt_ota
    libraries/rt_ota/libs/: librt_ota_noalgo_0.1.2_stm32l4_keil.lib
  group STM32_HAL
    libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_lptim.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c
  group cJSON
    packages/cJSON-latest/: cJSON.c cJSON_port.c cJSON_util.c
  group NetUtils
    packages/netutils-v1.1.0/telnet/: telnet.c
  group peripheral-samples
    packages/peripheral_samples-v0.4.0/: hwtimer_sample.c pwm_led_sample.c
  group robots
    packages/rt-robot-latest/chassis/: chassis.c
    packages/rt-robot-latest/controller/: controller.c inc_pid_controller.c pos_pid_controller.c
    packages/rt-robot-latest/encoder/: ab_phase_encoder.c encoder.c single_phase_encoder.c
    packages/rt-robot-latest/kinematics/: kinematics.c
    packages/rt-robot-latest/motor/: dual_pwm_motor.c motor.c single_pwm_motor.c
    packages/rt-robot-latest/protocol/: command.c ps2.c
    packages/rt-robot-latest/robot/: mobile_robot.c robot.c
    packages/rt-robot-latest/wheel/: wheel.c
  group stm32_sdio
    packages/stm32_sdio-v1.0.2/: stm32_sdio.c
  group tcpserver
    packages/tcpserver-latest/: tcpserver.c tcpserver_sample.c
  group CORTEX-M4
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_w25qxx.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    rt-thread/components/libc/compilers/common/: gmtime_r.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
